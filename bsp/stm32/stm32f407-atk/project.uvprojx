# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\..\..\libcpu\arm\common;..\libraries\HAL_Drivers;packages\LVGL-v8.3.8\src\extra\libs\fsdrv;packages\LVGL-v8.3.8\src\extra\others\gridnav;packages\LVGL-v8.3.8\src\extra\others\fragment;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.8\src\extra\others\ime;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src\draw\swm341_dma2d;applications;packages\LVGL-v8.3.8\src\widgets;packages\LVGL-v8.3.8\src\extra\themes\basic;packages\LVGL-v8.3.8\src\extra\widgets\menu;packages\LVGL-v8.3.8\src\extra\layouts\flex;packages\LVGL-v8.3.8\src\core;packages\LVGL-v8.3.8\src\draw\stm32_dma2d;packages\LVGL-v8.3.8\src\draw\nxp\vglite;packages\LVGL-v8.3.8\src\extra\widgets\tileview;packages\LVGL-v8.3.8\src\extra\layouts;packages\LVGL-v8.3.8\src\hal;..\..\..\components\drivers\spi;board\ports\mytouch;packages\LVGL-v8.3.8\src\draw;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src\draw\arm2d;packages\LVGL-v8.3.8\src\extra\libs\ffmpeg;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\stdio;applications\lvgl;packages\LVGL-v8.3.8\src\extra\others\msg;packages\LVGL-v8.3.8\src\extra\themes\mono;packages\LVGL-v8.3.8\src\extra\layouts\grid;packages\LVGL-v8.3.8\src\extra\widgets\keyboard;packages\LVGL-v8.3.8\src\extra\others\monkey;packages\LVGL-v8.3.8\src\extra\others\snapshot;packages\LVGL-v8.3.8\src\extra\widgets\colorwheel;packages\LVGL-v8.3.8\src\extra\widgets\msgbox;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;packages\LVGL-v8.3.8\src\extra\widgets\imgbtn;packages\LVGL-v8.3.8\src\extra\widgets\calendar;packages\LVGL-v8.3.8\src\draw\sw;packages\LVGL-v8.3.8\src\extra\widgets\meter;packages\LVGL-v8.3.8\src\extra;packages\LVGL-v8.3.8\src\extra\themes\default;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src\misc;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;applications\lvgl\demo;packages\LVGL-v8.3.8\src\extra\widgets\spinbox;packages\LVGL-v8.3.8\src\draw\renesas;packages\LVGL-v8.3.8\env_support\rt-thread\squareline\ui\lvgl;..\libraries\HAL_Drivers\config;.;..\..\..\components\finsh;..\libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.8\src\extra\libs\freetype;packages\LVGL-v8.3.8\src\extra\widgets\list;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src\extra\widgets\span;..\..\..\components\dfs\dfs_v1\include;packages\LVGL-v8.3.8\src\font;packages\LVGL-v8.3.8\src\extra\libs;packages\LVGL-v8.3.8\src\draw\nxp\pxp;packages\LVGL-v8.3.8\env_support\rt-thread;packages\LVGL-v8.3.8\src\extra\widgets\animimg;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\delay;..\..\..\components\libc\compilers\common\extension;packages\LVGL-v8.3.8\src\extra\widgets\led;packages\LVGL-v8.3.8\src\extra\widgets\chart;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;packages\LVGL-v8.3.8\src\extra\libs\bmp;..\..\..\components\drivers\include;packages\LVGL-v8.3.8\src\extra\libs\qrcode;packages\LVGL-v8.3.8\src\extra\others;board\CubeMX_Config\Core\Inc;packages\LVGL-v8.3.8\src\extra\libs\sjpg;packages\LVGL-v8.3.8\src\extra\widgets;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\LVGL-v8.3.8\src\extra\widgets\spinner;packages\LVGL-v8.3.8\src\extra\themes;packages\LVGL-v8.3.8\src\extra\others\imgfont;packages\LVGL-v8.3.8\src\extra\widgets\tabview;..\..\..\include;packages\LVGL-v8.3.8\src\extra\libs\rlottie;board\ports;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;board;packages\LVGL-v8.3.8\src\extra\libs\gif;packages\LVGL-v8.3.8\src\extra\libs\png;packages\LVGL-v8.3.8\src\extra\widgets\win;packages\LVGL-v8.3.8\env_support\rt-thread\squareline;packages\LVGL-v8.3.8\src\draw\sdl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c test_timer.c adc_task.c app.c adc_code.c dcmotor.c dcmotor_tim.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Core/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_mylcd.c drv_sram.c lcd.c
    board/ports/mytouch/: 24cxx.c ctiic.c ft5206.c gt9xxx.c myiic.c touch.c
    ../libraries/HAL_Drivers/: drv_adc.c drv_common.c drv_dac.c drv_gpio.c drv_pwm.c drv_soft_spi.c drv_spi.c drv_tim.c drv_usart.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dac.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    packages/LVGL-v8.3.8/src/font/: lv_font_montserrat_30.c lv_font_montserrat_10.c lv_font_loader.c lv_font_montserrat_24.c lv_font_montserrat_32.c lv_font_montserrat_20.c lv_font_simsun_16_cjk.c lv_font_montserrat_34.c lv_font_montserrat_26.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_16.c lv_font_montserrat_42.c lv_font_montserrat_28.c lv_font_montserrat_8.c lv_font_montserrat_44.c lv_font_montserrat_18.c lv_font_unscii_16.c lv_font_montserrat_48.c lv_font_montserrat_40.c lv_font_dejavu_16_persian_hebrew.c lv_font.c lv_font_unscii_8.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28_compressed.c lv_font_montserrat_12.c lv_font_montserrat_46.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_montserrat_22.c
    packages/LVGL-v8.3.8/src/misc/: lv_color.c lv_utils.c lv_anim_timeline.c lv_log.c lv_async.c lv_tlsf.c lv_lru.c lv_style_gen.c lv_area.c lv_txt.c lv_fs.c lv_printf.c lv_templ.c lv_timer.c lv_txt_ap.c lv_math.c lv_anim.c lv_bidi.c lv_style.c lv_gc.c lv_ll.c lv_mem.c
    packages/LVGL-v8.3.8/src/draw/: lv_draw_rect.c lv_draw.c lv_draw_transform.c lv_draw_triangle.c lv_draw_arc.c lv_img_decoder.c lv_draw_img.c lv_img_buf.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_img_cache.c
    packages/LVGL-v8.3.8/src/draw/sdl/: lv_draw_sdl_line.c lv_draw_sdl_rect.c lv_draw_sdl.c lv_draw_sdl_layer.c lv_draw_sdl_composite.c lv_draw_sdl_bg.c lv_draw_sdl_texture_cache.c lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_arc.c lv_draw_sdl_polygon.c lv_draw_sdl_utils.c lv_draw_sdl_stack_blur.c lv_draw_sdl_img.c
    packages/LVGL-v8.3.8/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_posix.c lv_fs_stdio.c lv_fs_fatfs.c
    packages/LVGL-v8.3.8/src/draw/nxp/vglite/: lv_vglite_utils.c lv_draw_vglite.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_vglite_buf.c
    packages/LVGL-v8.3.8/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.8/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.8/src/widgets/: lv_dropdown.c lv_arc.c lv_img.c lv_textarea.c lv_btn.c lv_canvas.c lv_line.c lv_checkbox.c lv_label.c lv_objx_templ.c lv_roller.c lv_slider.c lv_table.c lv_switch.c lv_bar.c lv_btnmatrix.c
    packages/LVGL-v8.3.8/src/draw/sw/: lv_draw_sw_dither.c lv_draw_sw_img.c lv_draw_sw_rect.c lv_draw_sw.c lv_draw_sw_letter.c lv_draw_sw_polygon.c lv_draw_sw_transform.c lv_draw_sw_gradient.c lv_draw_sw_arc.c lv_draw_sw_layer.c lv_draw_sw_line.c lv_draw_sw_blend.c
    packages/LVGL-v8.3.8/src/core/: lv_obj_pos.c lv_event.c lv_obj.c lv_obj_draw.c lv_indev_scroll.c lv_indev.c lv_refr.c lv_group.c lv_obj_scroll.c lv_obj_tree.c lv_obj_style_gen.c lv_disp.c lv_obj_class.c lv_theme.c lv_obj_style.c
    packages/LVGL-v8.3.8/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.8/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.8/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.8/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.8/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.8/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.8/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.8/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.8/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.3.8/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.8/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.8/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.8/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.8/src/draw/nxp/pxp/: lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_draw_pxp_blend.c
    packages/LVGL-v8.3.8/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.8/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.8/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.8/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.8/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.8/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.8/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.8/src/extra/: lv_extra.c
    packages/LVGL-v8.3.8/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.8/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.8/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.8/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.8/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.8/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.8/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.8/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.8/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.8/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.8/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.8/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.8/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.8/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.8/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.8/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.8/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.8/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.8/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.8/src/extra/others/gridnav/: lv_gridnav.c
  group LVGL-demo
    applications/lvgl/demo/: lv_demo_calendar.c lv_demo.c lv_demo_mine.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.8/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    packages/LVGL-v8.3.8/env_support/rt-thread/squareline/: lv_ui_entry.c
    packages/LVGL-v8.3.8/env_support/rt-thread/squareline/ui/components/: ui_comp_hook.c
  group POSIX
    ../../../components/libc/posix/delay/: delay.c
